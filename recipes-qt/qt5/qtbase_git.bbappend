PACKAGECONFIG += " \
	glib \
	no-opengl \
	fontconfig \
	gif \
	sql-sqlite \
	linuxfb \
	icu \
	openssl \
	libs \
	"
